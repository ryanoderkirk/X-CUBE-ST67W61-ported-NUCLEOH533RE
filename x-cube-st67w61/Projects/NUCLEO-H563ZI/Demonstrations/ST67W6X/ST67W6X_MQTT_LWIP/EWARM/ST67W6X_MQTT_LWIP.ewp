# IAR project ST67W6X_MQTT_LWIP.ewp, settings and files
configuration ST67W6X_MQTT_LWIP (ARM, debug)
  General.OGChipSelectEditMenu: STM32H563ZI ST STM32H563ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8; ST67_ARCH=W6X_ARCH_T02; LFS_CONFIG=lfs_util_config.h; USE_HAL_DRIVER; STM32H563xx
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ../Core/Inc; ../X-CUBE-MEMS1/Target; ../ST67W6X/App; ../Appli/App; ../Appli/Target; ../ST67W6X/Target; ../littlefs/Target; ../LWIP/App; ../LWIP/Target; ../LWIP/Target/arch; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/; ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/; ../../../../../../Drivers/CMSIS/RTOS2/Include/; ../../../../../../Middlewares/Third_Party/cJSON; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Api; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core; ../../../../../../Middlewares/Third_Party/LwIP/src/include/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/netif/ppp/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/priv/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/lwip/prot/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/stdc/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/net/; ../../../../../../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa/; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at; ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus; ../../../../../../Middlewares/Third_Party/MQTT-C/include; ../../../../../../Middlewares/Third_Party/littlefs; ../../../../../../Drivers/BSP/Components/lsm6dsv16x; ../../../../../../Drivers/BSP/Components/lis2duxs12; ../../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../../Drivers/BSP/Components/lsm6dso16is; ../../../../../../Drivers/BSP/Components/sht40ad1b; ../../../../../../Drivers/BSP/Components/lps22df; ../../../../../../Drivers/BSP/Components/stts22h; ../../../../../../Drivers/BSP/IKS4A1; ../../../../../../Drivers/BSP/Components/Common; ../X-CUBE-MEMS1/App
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: configTASK_NOTIFICATION_ARRAY_ENTRIES=8
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ST67W6X_MQTT_LWIP.bin
  ILINK.IlinkOutputFile: ST67W6X_MQTT_LWIP.out
  ILINK.IlinkIcfFile: stm32h563xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h563xx.s
  group Application/User/Appli/App
    ../Appli/App/: main_app.c
  group Application/User/Appli/Target
    ../Appli/Target/: logshell_ctrl.c
  group Application/User/Core
    ../Core/Src/: app_freertos.c main.c stm32h5xx_hal_msp.c stm32h5xx_hal_timebase_tim.c stm32h5xx_it.c stm32h5xx_nucleo_bus.c
  group Application/User/littlefs/Target
    ../littlefs/Target/: lfs_easyflash.c lfs_flash.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c lwip_netif.c
  group Application/User/ST67W6X/App
    ../ST67W6X/App/: app_st67w6x.c
  group Application/User/ST67W6X/Target
    ../ST67W6X/Target/: spi_port.c
  group Application/User/X-CUBE-MEMS1/App
    ../X-CUBE-MEMS1/App/: sys_sensors.c
  group Doc
    ../: readme.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lis2duxs12/: lis2duxs12.c lis2duxs12_reg.c
    ../../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../../Drivers/BSP/Components/lps22df/: lps22df.c lps22df_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dso16is/: lsm6dso16is.c lsm6dso16is_reg.c
    ../../../../../../Drivers/BSP/Components/lsm6dsv16x/: lsm6dsv16x.c lsm6dsv16x_reg.c
    ../../../../../../Drivers/BSP/Components/sht40ad1b/: sht40ad1b.c sht40ad1b_reg.c
    ../../../../../../Drivers/BSP/Components/stts22h/: stts22h.c stts22h_reg.c
  group Drivers/BSP/IKS4A1
    ../../../../../../Drivers/BSP/IKS4A1/: iks4a1_env_sensors.c iks4a1_env_sensors_ex.c iks4a1_motion_sensors.c iks4a1_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Drivers/STM32H5xx_HAL_Driver
    ../../../../../../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_i2c.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_rtc.c stm32h5xx_hal_rtc_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Middlewares/cJSON/Data Exchange/cJSON
    ../../../../../../Middlewares/Third_Party/cJSON/: cJSON.c
  group Middlewares/LittleFS/File System/LittleFS
    ../../../../../../Middlewares/Third_Party/littlefs/: lfs.c lfs_util.c
  group Middlewares/LwIP/Network/LwIP
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c slipif.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/MQTT-C/Data Exchange/MQTT-C
    ../../../../../../Middlewares/Third_Party/MQTT-C/src/: mqtt.c mqtt_pal.c
  group Middlewares/RTOS2/CMSIS/RTOS2/Core/TZ_Non_Supported
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group Middlewares/RTOS2/CMSIS/RTOS2/Heap/Heap_4
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/ST67W6X_Network_Driver/Network/ATDriver
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Misc/: common_parser.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_at/: modem_cmd_handler.c w61_at_ble.c w61_at_common.c w61_at_mqtt.c w61_at_net.c w61_at_sys.c w61_at_wifi.c
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Driver/W61_bus/: spi_iface.c w61_io.c
  group Middlewares/ST67W6X_Network_Driver/Network/ServiceAPI
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Core/: w6x_ble.c w6x_http.c w6x_mqtt.c w6x_net.c w6x_netif.c w6x_ota.c w6x_sys.c w6x_wifi.c
  group Middlewares/ST67W6X_Network_Driver/Network/Utilities/Logging
    ../../../../../../Middlewares/ST/ST67W6X_Network_Driver/Utils/Logging/: logging.c
